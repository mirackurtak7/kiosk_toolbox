Commit message: Update dolly.urdf

File: ali_rob/dolly.urdf (robot description, URDF)
Before this commit: robot dolly, 5 links, 4 joints
Joints:
- removed joint lidar_joint
- added joint laser_frame: type fixed, parent base_link, child lidar, origin xyz=0 0 0.1 rpy=0 0 0
